# Keil uVision project exactle_fit.uvprojx, settings and files
target exactle_fit (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: Apollo 512 BGA Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.0.8.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: exactle_fit +hex
  AfterMake: fromelf --bin --output bin\exactle_fit.bin bin\exactle_fit.axf
  AfterMake: fromelf -cedrst --output bin\exactle_fit.txt bin\exactle_fit.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_PACKAGE_BGA HCI_TR_UART keil
  c include: ../../../../../devices;../../../../../mcu/apollo;../../../../../utils;../../../bsp;../src;..\src;..\..\..\..\..\third_party\FreeRTOS\Source\include;..\..\..\..\..\third_party\FreeRTOS\Source;..\..\..\..\..\third_party\FreeRTOS\Source\portable\MemMang;..\..\..\..\..\third_party\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\RTT;..\src\common;..\src\transfer;..\src\ble
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  scatter file: .\exactle_fit.sct
  link misc: ../../../../../mcu/apollo/hal/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group src
    ../src/: rtos.c freertos_fit.c interrupt_handlers.c
    ../src/common/: crc_32.c
  group keil
    ./: startup_keil.s
  group lib
    ../../../../../mcu/apollo/hal/keil/bin/: libam_hal.lib
    ../../../bsp/keil/bin/: libam_bsp.lib
  group Source
    ../../../../../third_party/FreeRTOS/Source/: event_groups.c list.c queue.c tasks.c timers.c
  group ARM_CM4F
    ../../../../../third_party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group MemMang
    ../../../../../third_party/FreeRTOS/Source/portable/MemMang/: heap_2.c
  group RTT
    ../RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_KEIL.c
  group transfer
    ../src/transfer/: transfer_driver.c transfer_profile.c transfer_task.c mode_config.c
    ../src/ble/: ble_config.c
